# Keil uVision project littleDrone.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: littleDrone +hex
  c flags: Optim=3 uC99=1 wLevel=2
  c define: STM32F103xB,u8=uint8_t,u16=uint16_t,s16=int16_t,s32=int32_t,s8=int8_t,u32=uint32_t,USE_HAL_DRIVER
  c include: ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\CMSIS\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Inc;..\Src;..\Src\drivers;..\Src\scheduler
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group LIB
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group DRIVER
    ../Src/drivers/: hmc5883l.c i2.c mpu6050.c ms5611.c nrf24l01.c
  group SRC
    ../Src/scheduler/: scheduler.c
    ../Src/: ANO_DT.c control.c fc_tasks.c filter.c HAL_acc.c HAL_baro.c HAL_gyro.c HAL_mag.c HAL_motor.c HAL_rc.c imu.c led.c main.c maths.c schedule_tasks.c stmflash.c
  group SYS
    ../Src/: stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c sys.c usart.c delay.c
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
